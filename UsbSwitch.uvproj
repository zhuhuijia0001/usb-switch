# Keil uVision project UsbSwitch.uvproj, settings and files
target UsbSwitch (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UsbSwitch +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\bsp;.\app;.\cfg;.\dev;.\rtos\include;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\USB\STM32_USB-FS-Device_DriverV3.1.1\inc;.\USB\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep *.o(.rti_fn.*)
  group app
    ./app/: trace.h Packet.c Packet.h Protocol.h Task.h Task.c main.c
  group bsp
    ./bsp/: board.h stm32f10x_it.h usart.h board.c stm32f10x_it.c usart.c gpio_map.h Switch.c usb.c usb.h
  group rt-thread
    ./rtos/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c signal.c
  group rt-thread-ports
    ./cpuport/arm/common/: backtrace.c div0.c showmem.c
    ./cpuport/arm/cortex-m3/: cpuport.c context_rvds.S
  group STM32F10X_FW_CMSIS_Device
    ./Libraries/CMSIS/CM3/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./Libraries/CMSIS/CM3/DeviceSupport/startup/arm/: startup_stm32f10x_md.s
  group STM32F10X_FW_CMSIS_core
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
  group STM32F10X_FW_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cfg
    ./cfg/: rtconfig.h stm32f10x_conf.h
  group dev
    ./dev/drivers/: serial.c completion.c dataqueue.c
  group USB
    ./USB/USB/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USBCFG
    ./USB/STM32_USB-FS-Device_DriverV3.1.1/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
